# Enable wider codec support for real-world video sites such as YouTube.
PACKAGECONFIG:append = " proprietary-codecs"
